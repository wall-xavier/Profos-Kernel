## net/profpro/Kconfig
```kconfig
config PROFPRO
	tristate "ProfPro Protocol Support"
	default n
	help
		Enable the ProfPro Protocol
```
